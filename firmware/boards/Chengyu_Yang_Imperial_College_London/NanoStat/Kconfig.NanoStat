## firmware/boards/Chengyu_Yang_Imperial_College_London/NanoStat/board.yml
```yaml
board:
  name: NanoStat
  vendor: Chengyu_Yang_Imperial_College_London
  socs:
    - name: nrf52840
```
